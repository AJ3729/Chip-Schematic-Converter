* Auto-generated SPICE netlist

C1 n0 0 1u
D1 n1 0 DC 5V
D2 n2 0 DC 5V
R1 n4 0 1k
I1 n5 0 1m
I2 n5 0 1m
R2 n6 0 1k
I1 n0 0 DC 1mA
R3 n7 0 1k

.end
