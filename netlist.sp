* Auto-generated SPICE netlist (NO OCR values)
* Values are placeholders.

C1 n3 n3 1u
V1 n5 n5 DC 5V
V2 n2 n2 DC 5V
R1 n4 n4 1k
L1 n4 n4 1m
L2 n2 n2 1m
R2 n3 n3 1k
I1 n4 n4 DC 1mA
R3 n1 n1 1k

.op
.end
